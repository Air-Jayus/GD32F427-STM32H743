/* Copyright (C) 2019 *****************************************************************************
									 杭州科强智能控制系统有限公司
====================================================================================================
项目名称：T6H5型注塑机控制器
项目简介：新一代注塑机控制器的软、硬件平台。软件方面要达到易扩展、易维护之目的。

======================================== 文   件    信   息 ========================================
文件名称：Fun.c
文件说明：部分基础函数。

作    者：WlZ
编写时间：2024.9
======================================== 修   改    历   史 ========================================
修 改 人：
修改日期：
修改说明：

修 改 人：
修改日期：
修改说明：
======================================== 其   它    说   明 ========================================
1、（驱动程序还是应用程序）
2、（使用硬件等资源情况）
3、（其中函数调用注意事项）
4、（函数使用的算法等情况）

****************************************************************************************************/
//#define mSysDebug				

#ifndef Fun_c
	#define Fun_c
#endif

#include "Include.h"
/*======================================== 模块内有效宏定义 =======================================*/


/*======================================= 模块内有效变量定义 ======================================*/
const U8 auchCRCHi[]=  
{  
	0x00, 0xC1, 0x81, 0x40, 0x01, 0xC0, 0x80, 0x41, 0x01, 0xC0, 0x80, 0x41, 0x00, 0xC1, 0x81,  
	0x40, 0x01, 0xC0, 0x80, 0x41, 0x00, 0xC1, 0x81, 0x40, 0x00, 0xC1, 0x81, 0x40, 0x01, 0xC0,  
	0x80, 0x41, 0x01, 0xC0, 0x80, 0x41, 0x00, 0xC1, 0x81, 0x40, 0x00, 0xC1, 0x81, 0x40, 0x01,  
	0xC0, 0x80, 0x41, 0x00, 0xC1, 0x81, 0x40, 0x01, 0xC0, 0x80, 0x41, 0x01, 0xC0, 0x80, 0x41,  
	0x00, 0xC1, 0x81, 0x40, 0x01, 0xC0, 0x80, 0x41, 0x00, 0xC1, 0x81, 0x40, 0x00, 0xC1, 0x81,  
	0x40, 0x01, 0xC0, 0x80, 0x41, 0x00, 0xC1, 0x81, 0x40, 0x01, 0xC0, 0x80, 0x41, 0x01, 0xC0,  
	0x80, 0x41, 0x00, 0xC1, 0x81, 0x40, 0x00, 0xC1, 0x81, 0x40, 0x01, 0xC0, 0x80, 0x41, 0x01,  
	0xC0, 0x80, 0x41, 0x00, 0xC1, 0x81, 0x40, 0x01, 0xC0, 0x80, 0x41, 0x00, 0xC1, 0x81, 0x40,  
	0x00, 0xC1, 0x81, 0x40, 0x01, 0xC0, 0x80, 0x41, 0x01, 0xC0, 0x80, 0x41, 0x00, 0xC1, 0x81,  
	0x40, 0x00, 0xC1, 0x81, 0x40, 0x01, 0xC0, 0x80, 0x41, 0x00, 0xC1, 0x81, 0x40, 0x01, 0xC0,  
	0x80, 0x41, 0x01, 0xC0, 0x80, 0x41, 0x00, 0xC1, 0x81, 0x40, 0x00, 0xC1, 0x81, 0x40, 0x01,  
	0xC0, 0x80, 0x41, 0x01, 0xC0, 0x80, 0x41, 0x00, 0xC1, 0x81, 0x40, 0x01, 0xC0, 0x80, 0x41,  
	0x00, 0xC1, 0x81, 0x40, 0x00, 0xC1, 0x81, 0x40, 0x01, 0xC0, 0x80, 0x41, 0x00, 0xC1, 0x81,  
	0x40, 0x01, 0xC0, 0x80, 0x41, 0x01, 0xC0, 0x80, 0x41, 0x00, 0xC1, 0x81, 0x40, 0x01, 0xC0,  
	0x80, 0x41, 0x00, 0xC1, 0x81, 0x40, 0x00, 0xC1, 0x81, 0x40, 0x01, 0xC0, 0x80, 0x41, 0x01,  
	0xC0, 0x80, 0x41, 0x00, 0xC1, 0x81, 0x40, 0x00, 0xC1, 0x81, 0x40, 0x01, 0xC0, 0x80, 0x41,  
	0x00, 0xC1, 0x81, 0x40, 0x01, 0xC0, 0x80, 0x41, 0x01, 0xC0, 0x80, 0x41, 0x00, 0xC1, 0x81,  
	0x40  
};  
  
const U8 auchCRCLo[] =  
{  
	0x00, 0xC0, 0xC1, 0x01, 0xC3, 0x03, 0x02, 0xC2, 0xC6, 0x06, 0x07, 0xC7, 0x05, 0xC5, 0xC4,  
	0x04, 0xCC, 0x0C, 0x0D, 0xCD, 0x0F, 0xCF, 0xCE, 0x0E, 0x0A, 0xCA, 0xCB, 0x0B, 0xC9, 0x09,  
	0x08, 0xC8, 0xD8, 0x18, 0x19, 0xD9, 0x1B, 0xDB, 0xDA, 0x1A, 0x1E, 0xDE, 0xDF, 0x1F, 0xDD,  
	0x1D, 0x1C, 0xDC, 0x14, 0xD4, 0xD5, 0x15, 0xD7, 0x17, 0x16, 0xD6, 0xD2, 0x12, 0x13, 0xD3,  
	0x11, 0xD1, 0xD0, 0x10, 0xF0, 0x30, 0x31, 0xF1, 0x33, 0xF3, 0xF2, 0x32, 0x36, 0xF6, 0xF7,  
	0x37, 0xF5, 0x35, 0x34, 0xF4, 0x3C, 0xFC, 0xFD, 0x3D, 0xFF, 0x3F, 0x3E, 0xFE, 0xFA, 0x3A,  
	0x3B, 0xFB, 0x39, 0xF9, 0xF8, 0x38, 0x28, 0xE8, 0xE9, 0x29, 0xEB, 0x2B, 0x2A, 0xEA, 0xEE,  
	0x2E, 0x2F, 0xEF, 0x2D, 0xED, 0xEC, 0x2C, 0xE4, 0x24, 0x25, 0xE5, 0x27, 0xE7, 0xE6, 0x26,  
	0x22, 0xE2, 0xE3, 0x23, 0xE1, 0x21, 0x20, 0xE0, 0xA0, 0x60, 0x61, 0xA1, 0x63, 0xA3, 0xA2,  
	0x62, 0x66, 0xA6, 0xA7, 0x67, 0xA5, 0x65, 0x64, 0xA4, 0x6C, 0xAC, 0xAD, 0x6D, 0xAF, 0x6F,  
	0x6E, 0xAE, 0xAA, 0x6A, 0x6B, 0xAB, 0x69, 0xA9, 0xA8, 0x68, 0x78, 0xB8, 0xB9, 0x79, 0xBB,  
	0x7B, 0x7A, 0xBA, 0xBE, 0x7E, 0x7F, 0xBF, 0x7D, 0xBD, 0xBC, 0x7C, 0xB4, 0x74, 0x75, 0xB5,  
	0x77, 0xB7, 0xB6, 0x76, 0x72, 0xB2, 0xB3, 0x73, 0xB1, 0x71, 0x70, 0xB0, 0x50, 0x90, 0x91,  
	0x51, 0x93, 0x53, 0x52, 0x92, 0x96, 0x56, 0x57, 0x97, 0x55, 0x95, 0x94, 0x54, 0x9C, 0x5C,  
	0x5D, 0x9D, 0x5F, 0x9F, 0x9E, 0x5E, 0x5A, 0x9A, 0x9B, 0x5B, 0x99, 0x59, 0x58, 0x98, 0x88,  
	0x48, 0x49, 0x89, 0x4B, 0x8B, 0x8A, 0x4A, 0x4E, 0x8E, 0x8F, 0x4F, 0x8D, 0x4D, 0x4C, 0x8C,  
	0x44, 0x84, 0x85, 0x45, 0x87, 0x47, 0x46, 0x86, 0x82, 0x42, 0x43, 0x83, 0x41, 0x81, 0x80,  
	0x40  
};  

/*======================================= 模块内有效函数声明 ======================================*/


/****************************************************************************************************
函数名称：int main(void)
函数说明：主函数
输入参数：
返 回 值：
其    它：为方便本文件中函数调试而设
****************************************************************************************************/
#ifdef mSysDebug
    
int main(void)
{           
	       
	do{
	
	}while(mTrue);
}
#endif	//mSysDebug


/****************************************************************************************************
函数名称：CRC计算
函数说明：使用F7硬件进行计算 8位数据需要一个AHB周期
输入参数：cData--新的计算数据	Crc--累计计算的结果
返 回 值：CRC计算结果
其    它：
****************************************************************************************************/
/*void CRC_CCITT_init(void)
{
	volatile U32 buff;
	RCC->AHB1ENR |= 1<<12;  	//开启CRC时钟
	CRC->INIT = 0;				//CRC初值
	CRC->POL = 0x1021;		//CRC多项式
	buff = 1<<3;					//CRC位宽
	buff |= 1;						//CRC复位
	CRC->CR = buff;
}*/

//U16 Cal_CRC(U8 cData,U16 Crc)
//{
//	CRC->INIT = Crc;    //初值
//	*(uint8_t *)(void *)(&CRC->DR) = cData;
//	return CRC->DR;
//}
/*U16 Cal_CRC_ARR(U8 *AP,U16 Len)
{
	uint16_t i;
	CRC->INIT = 0;
	for (i = 0U; i < Len ; i++)
  {
    *(uint8_t *)(void *)(&CRC->DR) = AP[i];
  } 
	return CRC->DR;
}*/

/****************************************************************************************************
函数名称：CRC计算
函数说明：使用半字节查表法计算CRC_CCITT
输入参数：cData--新的计算数据	Crc--累计计算的结果
返 回 值：CRC计算结果
其    它：
****************************************************************************************************/
U16 Cal_CRC(U8 cData,U16 Crc)
{
	U8 cda;
	static U16 const Crc_Tab[16]={ /* CRC 余式表 */
		0x0000,0x1021,0x2042,0x3063,0x4084,0x50a5,0x60c6,0x70e7,
		0x8108,0x9129,0xa14a,0xb16b,0xc18c,0xd1ad,0xe1ce,0xf1ef};

	cData&=0x00ff;
	cda=((U8)(Crc>>8))>>4; 				/* 暂存CRC 的高四位 */
	Crc<<=4; 							/* CRC 右移4 位，相当于取CRC 的低12 位）*/
	Crc^=Crc_Tab[cda^(cData>>4)]; 		/* CRC 的高4 位和本字节的前半字节相加后查表计算CRC，然后加上上一次CRC 的余数 */
	cda=((U8)(Crc>>8))>>4;	 			/* 暂存CRC 的高4 位 */
	Crc<<=4; 							/* CRC 右移4 位， 相当于CRC 的低12 位） */
	Crc^=Crc_Tab[cda^(cData&0x0f)]; 	/* CRC 的高4 位和本字节的后半字节相加后查表计算CRC，然后再加上上一次CRC 的余数 */

	return(Crc);
}
/****************************************************************************************************
函数名称：U16数组CRC计算
函数说明：
输入参数：U16 *AP--数组指针，U16 Len--数组长度
返 回 值：CRC计算结果
其    它：
****************************************************************************************************/
U16 U16Array_Cal_CRC(U16 *AP,U16 Len)
{
	U16 Crc;
	U16 i;
	
	Crc=0;
	for(i=0;i<Len;i++)
	{
		Crc=Cal_CRC(AP[i]&0x00ff,Crc);
		Crc=Cal_CRC(AP[i]>>8,Crc);
	}
	return Crc;
}
/****************************************************************************************************
函数名称：U16数组累加和计算
函数说明：
输入参数：U16 *AP--数组指针，U16 Len--数组长度
返 回 值：计算结果
其    它：
****************************************************************************************************/
U16 U16Array_Cal_Sum(U16 *AP,U16 Len)
{
	U16 Sum,i;
	
	for(i=0,Sum=0;i<Len;i++)
		Sum+=AP[i];

	return Sum;
}
/****************************************************************************************************
函数名称：U32数组累加和计算
函数说明：
输入参数：U32 *AP--数组指针，U16 Len--数组长度
返 回 值：计算结果
其    它：
****************************************************************************************************/
U32 U32Array_Cal_Sum(U32 *AP,U32 Len)
{
	U32 Sum,i;
	
	for(i=0,Sum=0;i<Len;i++)
		Sum+=AP[i];

	return Sum;
}
/****************************************************************************************************
函数名称：U8数组ModbusCRC计算
函数说明：
输入参数：U8 *AP--数组指针，U16 Len--数组长度
返 回 值：CRC计算结果
其    它：
****************************************************************************************************/
U16 Modbus_CRC16(U8 *AP,U8 Len)  //20220719加
{  
  U8 uchCRCHi=0xff;  
  U8 uchCRCLo=0xff;  
  U16  uindex;  
  while(Len--)  
  {  
		uindex=uchCRCHi^*AP++;  
		uchCRCHi=uchCRCLo^auchCRCHi[uindex];  
		uchCRCLo=auchCRCLo[uindex];  
  }  
  return (uchCRCHi<<8|uchCRCLo);  
} 

