# Keil uVision project TopMxxEtherCAt.uvprojx, settings and files
target TopMxx (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: GD32F427ZG GigaDevice
  pack: GigaDevice.GD32F4xx_DFP.3.0.0
  cpu: IRAM(0x20000000,0x030000) IRAM2(0x10000000,0x010000) IROM(0x08000000,0x0100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Project +hex
  AfterMake: C:\Keil_v5\ARM\ARMCC\bin\fromelf.exe --bin --output output/TopMxx.bin output/Project.axf
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: GD32F427
  c include: ..\GD32F4xx_Firmware_Library\CMSIS\GD\GD32F4xx\Include;..\GD32F4xx_Firmware_Library\CMSIS;..\GD32F4xx_Firmware_Library\GD32F4xx_standard_peripheral\Include;..\;..\Application;..\Parameter;..\Driver;..\Action;..\EMaster
  library: MicroLIB
  memory RVCT4: ROM 0x8020000 size 0xe0000
  memory RVCT9: RAM 0x20000040 size 0x2ffc0
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Application
    ../: main.c
    ../Application/: Fun.c Alarm.c Action.c Boot_IAP.c Code.c DateTime.c HAI.c License.c Monitor.c Position.c Scheduler.c Temp.c Wave.c
  group CMSIS
    ../GD32F4xx_Firmware_Library/CMSIS/GD/GD32F4xx/Source/: system_gd32f4xx.c
  group GD32F4xx_Peripherals
    ../GD32F4xx_Firmware_Library/GD32F4xx_standard_peripheral/Source/: gd32f4xx_gpio.c gd32f4xx_rcu.c gd32f4xx_timer.c gd32f4xx_crc.c gd32f4xx_usart.c gd32f4xx_misc.c gd32f4xx_i2c.c gd32f4xx_can.c gd32f4xx_dbg.c gd32f4xx_spi.c gd32f4xx_fwdgt.c gd32f4xx_enet.c gd32f4xx_syscfg.c
  group Driver
    ../Driver/: Time_Drv.c Comm_Drv.c IIC_Drv.c LADC_Drv.c Can_Drv.c SimBus_Drv.c DIDO_Drv.c DigiLed_Drv.c HardPlat_Drv.c DAC_Drv.c HCIS300SD_Drv.c J5_PID_Drv.c HADC_Drv.c License_Drv.c MADC_Drv.c CanModule_Drv.c WDT_Drv.c KWhMeter_Drv.c CanOpen_Drv.c HiLectroM6_Drv.c TDSD_Drv.c VEICHISD_Drv.c ESSD_Drv.c EuRaSD_Drv.c HiLectroSD_Drv.c RobotCommunication_Drv.c ModrolSD_Drv.c Ecat_Drv.c Enet_Drv.c
  group Startup
    ../GD32F4xx_Firmware_Library/CMSIS/GD/GD32F4xx/Source/ARM/: startup_gd32f407_427.s
  group Parameter
    ../Parameter/: RPHA.c
  group Action
    ../Action/: ActConf.c MoldOpenClsAlg.c
  group EMaster
    ../EMaster/: ethercatbase.c ethercatcoe.c ethercatdc.c ethercaterror.c ethercatfoe.c ethercatinfo.c ethercatinit.c ethercatlist.c ethercatmain.c ethercatsii.c ethercatsoe.c nicdrive.c
software components: CMSIS:CORE 5.3.0
