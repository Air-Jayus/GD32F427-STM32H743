# Keil uVision project TopMxx.uvprojx, settings and files
target TopMxx (5060960::V5.06 update 7 for Certification (build 960)::.\ARMCC)
  device: STM32H743VGTx STMicroelectronics
  pack: Keil.STM32H7xx_DFP.4.1.3
  cpu: IRAM(0x24000000,0x80000) IRAM2(0x30000000,0x48000) IRAM3(0x38000000,0x10000) IROM(0x08000000,0x100000) IROM2(0x08100000,0x100000) CPUTYPE("Cortex-M7") FPU2 CLOCK(25000000) ELITTLE
  output: Project
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: GD32F427,STM32H743xx,USE_HAL_DRIVER,USE_FULL_LL_DRIVER
  c include: ..\STM32H7xx_Drivers\CMSIS\Device\ST\STM32H7xx\Include;..\STM32H7xx_Drivers\CMSIS\Include;..\STM32H7xx_Drivers\STM32H7xx_HAL_Driver\Inc;..\STM32H7xx_Drivers;..\GD32F4xx_Firmware_Library\CMSIS\GD\GD32F4xx\Include;..\GD32F4xx_Firmware_Library\CMSIS;..\GD32F4xx_Firmware_Library\GD32F4xx_standard_peripheral\Include;..\;..\Application;..\Parameter;..\Driver;..\Action
  library: MicroLIB
  memory RVCT4: ROM 0x8020000 size 0xe0000
  memory RVCT5: ROM 0x8100000 size 0x100000
  memory RVCT9: RAM 0x20000040 size 0x1ffc0
  memory RVCT10: RAM 0x24000000 size 0x80000
  group Application
    ../: main.c
    ../Application/: Fun.c
  group CMSIS
    ../STM32H7xx_Drivers/: system_stm32h7xx.c
  group GD32F4xx_Peripherals
    ../GD32F4xx_Firmware_Library/GD32F4xx_standard_peripheral/Source/: gd32f4xx_gpio.c gd32f4xx_rcu.c gd32f4xx_timer.c gd32f4xx_usart.c gd32f4xx_misc.c gd32f4xx_i2c.c gd32f4xx_can.c gd32f4xx_dbg.c gd32f4xx_spi.c gd32f4xx_fwdgt.c
  group Driver
    ../Driver/: Time_Drv.c Comm_Drv.c IIC_Drv.c LADC_Drv.c Can_Drv.c SimBus_Drv.c DIDO_Drv.c DigiLed_Drv.c DAC_Drv.c HADC_Drv.c MADC_Drv.c WDT_Drv.c
  group Startup
    ../STM32H7xx_Drivers/: startup_stm32h743xx.s
  group Parameter
    ../Parameter/: RPHA.c
  group LIb
    ../: Project.lib
software components: CMSIS:CORE 5.4.0
